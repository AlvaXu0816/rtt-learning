# Keil uVision project stack.uvprojx, settings and files
target stack (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stack
  AfterMake: fromelf  --bin  --output=led.bin  Objects\stack.axf
  AfterMake: fromelf  --text  -a -c  --output=led.dis  Objects\stack.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ./: main.c
  group cpu
    ./: start.s
